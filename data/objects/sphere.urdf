Commit message: Fix minor bugs

File: data/objects/sphere.urdf (robot description, URDF)
Before this commit: robot sphere.urdf, 1 links, 0 joints
Links:
- link my_link: mass None -> 0
